 //==================================================================
//================= @INCLUDES ======================================
//==================================================================
#include <stdio.h>
#include <string.h>
#include <stdlib.h>
//==================================================================
//================= @DEFINES =======================================
//==================================================================

//==================================================================
//================= @ENUMS =========================================
//==================================================================

//==================================================================
//================= @DATATYPES =====================================
//==================================================================
/* The ENVIRON variable contains the environment. */
extern char **environ;
//==================================================================
//================= @FUNCTION PROTOTYPE ============================
//==================================================================

//==================================================================
//================= @FUNCTION DEFINITION ===========================
//==================================================================

int main (int argc, char *argv[])
{
        char **pPvar = NULL;
	char *pFileName = NULL;

	if (argc != 2)
	{
		printf("Please provide arguments\n");
		return (-1);
	}
	
	/* print one by one string fomr array */
	for (pPvar = environ; *pPvar != NULL; pPvar++)
	{
		if (strstr(*pPvar, argv[1]) != NULL)
		{
			pFileName = strchr(*pPvar, '=');
			
			if (pFileName != NULL)
			{
				printf("%s\n", ++pFileName);
			}
		}
	}

	return 0;
}








